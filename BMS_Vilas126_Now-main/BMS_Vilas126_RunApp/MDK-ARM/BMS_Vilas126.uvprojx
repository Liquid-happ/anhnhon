# Keil uVision project BMS_Vilas126.uvprojx, settings and files
target BMS_Vilas126 (6140000::V6.14::ARMCLANG)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: BMS_Vilas126 +hex
  AfterMake: fromelf.exe --bin --output "$L@L.bin" "#L"
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xE
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include
  memory RVCT4: ROM 0x8010000 size 0x37800
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group Application/User/Core
    ../Core/Inc/: BQ769x2Header.h kalmanfilter.h dwin.h pylon_can.h bq_bms_pylon.h bq_bms_485.h bms_state.h led_indication.h led_flash.h ntc_table.h DS1307.h driver_w25qxx.h stm32f1xx_hal_conf.h
    ../Core/Src/: kalmanfilter.c dwin.c pylon_can.c bq_bms_pylon.c bq_bms_485.c bms_state.c led_indication.c led_flash.c ntc_table.c DS1307.c driver_w25qxx.c main.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_i2c.c stm32f1xx_hal_iwdg.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group rd_ota
    ../Core/rd_ota/: rd_control.c rd_flash.c RingBuffer.c Xmodem.c rd_sha256.c
software components: CMSIS:CORE 5.6.0
